# Keil uVision project GT1.uvprojx, settings and files
target GT1 (ARM-ADS)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: GT1 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;            ../Drivers/STM32F4xx_HAL_Driver/Inc;            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;            ../Middlewares/Third_Party/FatFs/src/drivers;            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;            ../Middlewares/Third_Party/FatFs/src;            ../Drivers/CMSIS/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c fatfs.c main.c bsp_driver_sd.c stm32f4xx_it.c usbd_conf.c usbd_cdc_if.c usbd_desc.c usb_device.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.1.0
